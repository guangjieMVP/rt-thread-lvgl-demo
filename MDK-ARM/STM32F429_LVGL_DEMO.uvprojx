# Keil uVision project STM32F429_LVGL_DEMO.uvprojx, settings and files
target LittleVGL_DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429_LVGL_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\DRIVE;..\APP;..\LVGL_UI;..\BSP\font;..\BSP\lcd;..\BSP\sdram;..\BSP\usart;..\BSP\tim;..\BSP\touch;..\LittleVGL\src;..\LittleVGL\src\lv_core;..\LittleVGL\src\lv_draw;..\LittleVGL\src\lv_font;..\LittleVGL\src\lv_gpu;..\LittleVGL\src\lv_hal;..\LittleVGL\src\lv_misc;..\LittleVGL\src\lv_themes;..\LittleVGL\src\lv_widgets;..\LittleVGL\examples\porting;..\LVGL_UI\lv_test_core;..\LVGL_UI\lv_test_fonts;..\LVGL_UI\lv_test_ref_imgs;..\LVGL_UI\lv_test_widgets;..\lv_examples;..\lv_examples\src\lv_ex_get_started;..\lv_examples\src\lv_demo_printer;..\lv_examples\src\lv_demo_printer\images;..\lv_examples\src\lv_ex_style;..\lvgl_test_app;..\lvgl_test_app\guider_fonts;..\lvgl_test_app\guider_customer_fonts;..\rtthread\3.0.3\include;..\rtthread\3.0.3\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../APP/: main.c stm32f4xx_it.c app-thread.c
  group BSP
    ../BSP/font/: fonts.c
    ../BSP/lcd/: bsp_lcd.c
    ../BSP/sdram/: bsp_sdram.c
    ../BSP/usart/: bsp_debug_usart.c
    ../BSP/tim/: bsp_general_tim.c
    ../BSP/touch/: gt9xx.c bsp_i2c_touch.c
  group lv_examples/assets
    ../lv_examples/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
  group lv_examples/src/lv_demo_benchmark
    ../lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
  group lv_examples/src/lv_demo_keypad_encoder
    ../lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c
  group lv_examples/src/lv_demo_printer
    ../lv_examples/src/lv_demo_printer/: lv_demo_printer.c lv_demo_printer_theme.c
    ../lv_examples/src/lv_demo_printer/images/: lv_demo_printer_icon_bright.c lv_demo_printer_icon_eco.c lv_demo_printer_icon_hue.c lv_demo_printer_icon_pc.c lv_demo_printer_icon_tel.c lv_demo_printer_icon_wifi.c lv_demo_printer_img_btn_bg_1.c lv_demo_printer_img_btn_bg_2.c lv_demo_printer_img_btn_bg_3.c lv_demo_printer_img_btn_bg_4.c lv_demo_printer_img_cloud.c lv_demo_printer_img_copy.c lv_demo_printer_img_internet.c lv_demo_printer_img_mobile.c lv_demo_printer_img_no_internet.c lv_demo_printer_img_phone.c lv_demo_printer_img_print.c lv_demo_printer_img_printer2.c lv_demo_printer_img_ready.c lv_demo_printer_img_scan.c lv_demo_printer_img_scan_example.c lv_demo_printer_img_setup.c lv_demo_printer_img_usb.c lv_demo_printer_img_wave.c
  group lv_examples/src/lv_demo_stress
    ../lv_examples/src/lv_demo_stress/: lv_demo_stress.c
  group lv_examples/src/lv_demo_widgets
    ../lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
  group lv_examples/src/lv_ex_get_started
    ../lv_examples/src/lv_ex_get_started/: lv_ex_get_started_1.c lv_ex_get_started_2.c lv_ex_get_started_3.c
  group lv_examples/src/lv_ex_style
    ../lv_examples/src/lv_ex_style/: lv_ex_style_1.c lv_ex_style_2.c lv_ex_style_3.c lv_ex_style_4.c lv_ex_style_5.c lv_ex_style_6.c lv_ex_style_7.c lv_ex_style_8.c lv_ex_style_9.c lv_ex_style_10.c lv_ex_style_11.c
  group lv_examples/src/lv_ex_widgets
    ../lv_examples/src/lv_ex_widgets/: lv_ex_templ.c
  group lvgl/src/lv_core
    ../LittleVGL/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lvgl/src/lv_draw
    ../LittleVGL/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/lv_font
    ../LittleVGL/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
  group lvgl/src/lv_gpu
    ../LittleVGL/src/lv_gpu/: lv_gpu_stm32_dma2d.c
  group lvgl/src/lv_hal
    ../LittleVGL/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/lv_misc
    ../LittleVGL/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/lv_themes
    ../LittleVGL/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group lvgl/src/lv_widgets
    ../LittleVGL/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lvgl/examples/porting
    ../LittleVGL/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../LittleVGL/: lv_conf.h
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group RT-Thread/src
    ../rtthread/3.0.3/bsp/: rtconfig.h
    ../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RT-Thread/port
    ../rtthread/3.0.3/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../rtthread/3.0.3/bsp/: board.c
  group lvgl_test_app
    ../lvgl_test_app/: events_init.c gui_guider.c setup_scr_screen.c
    ../lvgl_test_app/guider_fonts/: lv_font_simsun_12.c
